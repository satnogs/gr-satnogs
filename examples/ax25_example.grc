<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ax25_example</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>array</value></param>
<param><key>value</key><value>[0x0, 0x1, 0x2, 0x3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.02</value></param>
</block>
<block>
<key>satnogs_ax25_decoder_b</key>
<param><key>id</key><value>satnogs_ax25_decoder_b_0</value></param>
<param><key>promisc</key><value>True</value></param>
<param><key>addr</key><value>ABCD</value></param>
<param><key>ssid</key><value>0</value></param>
</block>
<block>
<key>satnogs_ax25_encoder_bf</key>
<param><key>id</key><value>satnogs_ax25_encoder_bf_0</value></param>
<param><key>dest_addr</key><value>ABCD</value></param>
<param><key>dest_ssid</key><value>0</value></param>
<param><key>src_addr</key><value>EFGH</value></param>
<param><key>src_ssid</key><value>0</value></param>
</block>
<block>
<key>satnogs_clear_text_msg_sink</key>
<param><key>id</key><value>satnogs_clear_text_msg_sink_0</value></param>
</block>
<block>
<key>satnogs_debug_msg_source</key>
<param><key>id</key><value>satnogs_debug_msg_source_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>msg</key><value>"HELLO EARTH WORLD FROM SPACE"</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>satnogs_udp_msg_source</key>
<param><key>id</key><value>satnogs_udp_msg_source_0</value></param>
<param><key>addr</key><value>"127.0.0.1"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>16886</value></param>
</block>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>satnogs_ax25_decoder_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_b_0</source_block_id><sink_block_id>satnogs_clear_text_msg_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_ax25_encoder_bf_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ax25_encoder_bf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_debug_msg_source_0</source_block_id><sink_block_id>satnogs_ax25_encoder_bf_0</sink_block_id><source_key>msg</source_key><sink_key>info</sink_key></connection>
<connection><source_block_id>satnogs_udp_msg_source_0</source_block_id><sink_block_id>satnogs_ax25_encoder_bf_0</sink_block_id><source_key>msg</source_key><sink_key>info</sink_key></connection>
</flow_graph>
