<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ax25_example</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_and_const_xx</key>
<param><key>id</key><value>blocks_and_const_xx_0</value></param>
<param><key>const</key><value>0x1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_and_const_xx</key>
<param><key>id</key><value>blocks_and_const_xx_0_0</value></param>
<param><key>const</key><value>0x1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x0</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>1</value></param>
<param><key>name</key><value>"AX.25 G3RUH"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>1</value></param>
<param><key>name</key><value>"AX.25"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>satnogs_ax25_decoder_bm</key>
<param><key>id</key><value>satnogs_ax25_decoder_bm_0</value></param>
<param><key>descrambling</key><value>True</value></param>
<param><key>max_frame_len</key><value>512</value></param>
<param><key>promisc</key><value>True</value></param>
<param><key>addr</key><value>'GND'</value></param>
<param><key>ssid</key><value>0</value></param>
</block>
<block>
<key>satnogs_ax25_decoder_bm</key>
<param><key>id</key><value>satnogs_ax25_decoder_bm_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>descrambling</key><value>False</value></param>
<param><key>max_frame_len</key><value>512</value></param>
<param><key>promisc</key><value>True</value></param>
<param><key>addr</key><value>'GND'</value></param>
<param><key>ssid</key><value>0</value></param>
</block>
<block>
<key>satnogs_ax25_encoder_mb</key>
<param><key>id</key><value>satnogs_ax25_encoder_mb_0</value></param>
<param><key>comment</key><value>In G3RUH, the preamble length should be at least 2
to allow the self synchronizing scrambler to sync</value></param>
<param><key>dest_addr</key><value>ABCD</value></param>
<param><key>dest_ssid</key><value>1</value></param>
<param><key>scramble</key><value>True</value></param>
<param><key>postamble_len</key><value>1</value></param>
<param><key>preamble_len</key><value>4</value></param>
<param><key>src_addr</key><value>CDEF</value></param>
<param><key>src_ssid</key><value>1</value></param>
</block>
<block>
<key>satnogs_ax25_encoder_mb</key>
<param><key>id</key><value>satnogs_ax25_encoder_mb_0_0</value></param>
<param><key>dest_addr</key><value>ABCD</value></param>
<param><key>dest_ssid</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scramble</key><value>False</value></param>
<param><key>postamble_len</key><value>1</value></param>
<param><key>preamble_len</key><value>1</value></param>
<param><key>src_addr</key><value>CDEF</value></param>
<param><key>src_ssid</key><value>1</value></param>
</block>
<block>
<key>satnogs_debug_msg_source</key>
<param><key>id</key><value>satnogs_debug_msg_source_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>"HELLO EARTH WORLD FROM SPACE"</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>satnogs_debug_msg_source_raw</key>
<param><key>id</key><value>satnogs_debug_msg_source_raw_0</value></param>
<param><key>delay</key><value>1.0</value></param>
<param><key>msg</key><value>[0xAA, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xAA]</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value></value></param>
<param><key>outstream</key><value>True</value></param>
<param><key>timestamp</key><value>False</value></param>
<param><key>format</key><value>1</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0_0</value></param>
<param><key>filename</key><value></value></param>
<param><key>outstream</key><value>True</value></param>
<param><key>timestamp</key><value>True</value></param>
<param><key>format</key><value>1</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value></value></param>
<param><key>outstream</key><value>True</value></param>
<param><key>timestamp</key><value>True</value></param>
<param><key>format</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_and_const_xx_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_and_const_xx_0_0</source_block_id><sink_block_id>blocks_uchar_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_0</source_block_id><sink_block_id>blocks_and_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_0_0</source_block_id><sink_block_id>blocks_and_const_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>blocks_not_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0</source_block_id><sink_block_id>blocks_not_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_bm_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0</sink_block_id><source_key>failed_pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_bm_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_bm_0_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0_0_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_ax25_encoder_mb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ax25_encoder_mb_0</source_block_id><sink_block_id>satnogs_ax25_decoder_bm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ax25_encoder_mb_0_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ax25_encoder_mb_0_0</source_block_id><sink_block_id>satnogs_ax25_decoder_bm_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_debug_msg_source_0</source_block_id><sink_block_id>satnogs_ax25_encoder_mb_0</sink_block_id><source_key>msg</source_key><sink_key>info</sink_key></connection>
<connection><source_block_id>satnogs_debug_msg_source_0</source_block_id><sink_block_id>satnogs_ax25_encoder_mb_0_0</sink_block_id><source_key>msg</source_key><sink_key>info</sink_key></connection>
<connection><source_block_id>satnogs_debug_msg_source_raw_0</source_block_id><sink_block_id>satnogs_ax25_encoder_mb_0</sink_block_id><source_key>msg</source_key><sink_key>info</sink_key></connection>
<connection><source_block_id>satnogs_debug_msg_source_raw_0</source_block_id><sink_block_id>satnogs_ax25_encoder_mb_0_0</sink_block_id><source_key>msg</source_key><sink_key>info</sink_key></connection>
</flow_graph>
