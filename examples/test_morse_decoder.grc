<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_morse_decoder</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Morse Decoder Simple Example</value></param>
</block>
<block>
<key>satnogs_morse_debug_source</key>
<param><key>id</key><value>satnogs_morse_debug_source_0</value></param>
<param><key>p</key><value>0.01</value></param>
<param><key>errors</key><value>True</value></param>
<param><key>debug_seq</key><value>"SATNOGS HELLO EARTH WORLD 123456789"</value></param>
<param><key>seq_pause_ms</key><value>1000</value></param>
<param><key>wpm</key><value>20</value></param>
</block>
<block>
<key>satnogs_morse_decoder</key>
<param><key>id</key><value>satnogs_morse_decoder_0</value></param>
<param><key>min_frame_len</key><value>3</value></param>
<param><key>unrecognized_char</key><value>ord('#')</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0</value></param>
<param><key>filename</key><value></value></param>
<param><key>outstream</key><value>True</value></param>
<param><key>timestamp</key><value>False</value></param>
<param><key>format</key><value>0</value></param>
</block>
<connection><source_block_id>satnogs_morse_debug_source_0</source_block_id><sink_block_id>satnogs_morse_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_morse_decoder_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
