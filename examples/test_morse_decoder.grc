<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_morse_decoder</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>satnogs_clear_text_msg_sink</key>
<param><key>id</key><value>satnogs_clear_text_msg_sink_0</value></param>
</block>
<block>
<key>satnogs_morse_debug_source</key>
<param><key>id</key><value>satnogs_morse_debug_source_0</value></param>
<param><key>p</key><value>0.01</value></param>
<param><key>errors</key><value>True</value></param>
<param><key>debug_seq</key><value>"XPGOLIAT HELLO EARTH WORLD 123456789"</value></param>
</block>
<block>
<key>satnogs_morse_decoder</key>
<param><key>id</key><value>satnogs_morse_decoder_0</value></param>
<param><key>unrecognized_char</key><value>ord('#')</value></param>
</block>
<connection><source_block_id>satnogs_morse_debug_source_0</source_block_id><sink_block_id>satnogs_morse_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_morse_decoder_0</source_block_id><sink_block_id>satnogs_clear_text_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
