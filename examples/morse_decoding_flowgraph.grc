<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>morse_decoding_flowgraph</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>const</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Signal Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>comment</key><value>The frequency of the CW signal</value></param>
<param><key>value</key><value>700.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_ratio</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>label</key><value>Noise Ratio</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>WAV or input sampling rate</value></param>
<param><key>value</key><value>8000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>comment</key><value>The number of taps depends on the number of samples
of a full period of the CW signal with frequency freq.</value></param>
<param><key>value</key><value>int(math.ceil(samp_rate/freq))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wpm</value></param>
<param><key>comment</key><value>Words Per Minute. ITU standard specifies it to 20.</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>6.25e-3</value></param>
<param><key>decay_rate</key><value>6.25e-3</value></param>
<param><key>gain</key><value>0.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>0.3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>noise_ratio</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>taps</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>const</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>const</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/surligas/workspace/gr-satnogs/examples/morse_ref.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Matched filter Energy</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>150000</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Input Signal</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Input Signal + Noise</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>AGC Signal</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>satnogs_cw_matched_filter_ff</key>
<param><key>id</key><value>satnogs_cw_matched_filter_ff_0</value></param>
<param><key>carrier_freq</key><value>freq</value></param>
<param><key>energy</key><value>True</value></param>
<param><key>sampling_rate</key><value>samp_rate</value></param>
<param><key>wpm</key><value>wpm</value></param>
</block>
<block>
<key>satnogs_cw_to_symbol</key>
<param><key>id</key><value>satnogs_cw_to_symbol_0</value></param>
<param><key>threshold</key><value>20e3</value></param>
<param><key>auto_config</key><value>True</value></param>
<param><key>conf_level</key><value>0.85</value></param>
<param><key>sampling_rate</key><value>samp_rate</value></param>
<param><key>wpm</key><value>20</value></param>
</block>
<block>
<key>satnogs_morse_decoder</key>
<param><key>id</key><value>satnogs_morse_decoder_0</value></param>
<param><key>unrecognized_char</key><value>ord('#')</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0</value></param>
<param><key>format</key><value>0</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>satnogs_cw_matched_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>satnogs_cw_to_symbol_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_cw_matched_filter_ff_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_cw_to_symbol_0</source_block_id><sink_block_id>satnogs_morse_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_morse_decoder_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
