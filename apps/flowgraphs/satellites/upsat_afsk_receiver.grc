<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>upsat_afsk_receiver</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>comment</key><value>FSK baud rate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>BB Gain RX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_rx</value></param>
<param><key>comment</key><value>Decimation factor
for the RX after the
SDR received samples</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>comment</key><value>The FSK frequency deviation</value></param>
<param><key>value</key><value>1.25e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>IF Gain RX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation_index</value></param>
<param><key>value</key><value>deviation / (baud_rate / 2.0)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>RF Gain RX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>comment</key><value>The RX center frequency
 of the system</value></param>
<param><key>value</key><value>145.835e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>samp_rate_rx/decimation_rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>2.5e6</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>20000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>width</key><value>60000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>(samp_rate / baud_rate)/(math.pi*modulation_index)</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.05</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>lo_offset</value></param>
<param><key>decim</key><value>decimation_rx</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain_rx</value></param>
<param><key>bw0</key><value>samp_rate_rx</value></param>
<param><key>freq0</key><value>rx_frequency - lo_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain_rx</value></param>
<param><key>gain0</key><value>rf_gain_rx</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>(4.0*baud_rate) / samp_rate</value></param>
<param><key>atten</key><value>60</value></param>
<param><key>taps</key><value>firdes.low_pass_2(32, 32, 0.8, 0.1, 60)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>name</key><value>"Clock Recovery"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>baud_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0</value></param>
<param><key>format</key><value>0</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0_0</value></param>
<param><key>format</key><value>1</value></param>
</block>
<block>
<key>satnogs_udp_msg_sink</key>
<param><key>id</key><value>satnogs_udp_msg_sink_0</value></param>
<param><key>addr</key><value>"10.2.110.42"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>16886</value></param>
</block>
<block>
<key>satnogs_upsat_fsk_frame_acquisition</key>
<param><key>id</key><value>satnogs_upsat_fsk_frame_acquisition_0</value></param>
<param><key>check_crc</key><value>False</value></param>
<param><key>preamble</key><value>[0x33]*8 </value></param>
<param><key>sync_word</key><value>[0x7A, 0x0E]</value></param>
<param><key>ax_25</key><value>True</value></param>
<param><key>manchester</key><value>False</value></param>
<param><key>whitening</key><value>False</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>satnogs_upsat_fsk_frame_acquisition_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_upsat_fsk_frame_acquisition_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_upsat_fsk_frame_acquisition_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_upsat_fsk_frame_acquisition_0</source_block_id><sink_block_id>satnogs_udp_msg_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
</flow_graph>
