<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>satnogs_fm_demod</value></param>
<param><key>author</key><value>Manolis Surligas (surligas@gmail.com)</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A generic FM demodulation block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>FM Generic Demodulation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_gain</value></param>
<param><key>comment</key><value>Decimation factor
for the RX after the
SDR received samples</value></param>
<param><key>value</key><value>satnogs.fm_demod_settings[rx_sdr_device]['audio_gain']</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_rx</value></param>
<param><key>comment</key><value>Decimation factor
for the RX after the
SDR received samples</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>satnogs.fm_demod_settings[rx_sdr_device]['decimation_rx']</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quadrature_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>samp_rate_rx / decimation_rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>satnogs.hw_rx_settings[rx_sdr_device]['samp_rate']</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>100e3</value></param>
<param><key>gain</key><value>12.0</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>width</key><value>60000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate_rx, 125000, 25000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>(2*math.pi*deviation)/audio_samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_antenna</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_bb_gain</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>125</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>32767</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>7355</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decoded_data_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/.satnogs/data/data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dev_args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_dev_args</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_correction_per_sec</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enable_iq_dump</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test.wav</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>lo_offset</value></param>
<param><key>decim</key><value>int(samp_rate_rx/filter_rate)</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_if_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/iq.dat</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>comment</key><value>16 kHz filter width, about right
for a standard 5 kHz Dev FM signal.</value></param>
<param><key>cutoff_freq</key><value>8000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>satnogs.handle_rx_antenna(rx_sdr_device, antenna)</value></param>
<param><key>bb_gain0</key><value>satnogs.handle_rx_bb_gain(rx_sdr_device, bb_gain)</value></param>
<param><key>bw0</key><value>samp_rate_rx</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>rx_freq - lo_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>satnogs.handle_rx_if_gain(rx_sdr_device, if_gain)</value></param>
<param><key>gain0</key><value>satnogs.handle_rx_rf_gain(rx_sdr_device, rf_gain)</value></param>
<param><key>args</key><value>satnogs.handle_rx_dev_args(rx_sdr_device, dev_args)</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_rf_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rigctl_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4532</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sdr_device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>usrpb200</value></param>
</block>
<block>
<key>satnogs_coarse_doppler_correction_cc</key>
<param><key>id</key><value>satnogs_coarse_doppler_correction_cc_0</value></param>
<param><key>sampling_rate</key><value>samp_rate_rx</value></param>
<param><key>target_freq</key><value>rx_freq</value></param>
</block>
<block>
<key>satnogs_iq_sink</key>
<param><key>id</key><value>satnogs_iq_sink_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>filename</key><value>iq_file_path</value></param>
<param><key>scale</key><value>32767</value></param>
<param><key>status</key><value>enable_iq_dump</value></param>
</block>
<block>
<key>satnogs_ogg_encoder</key>
<param><key>id</key><value>satnogs_ogg_encoder_0</value></param>
<param><key>filename</key><value>file_path</value></param>
<param><key>quality</key><value>1.0</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
</block>
<block>
<key>satnogs_tcp_rigctl_msg_source</key>
<param><key>id</key><value>satnogs_tcp_rigctl_msg_source_0</value></param>
<param><key>addr</key><value>"127.0.0.1"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>mode</key><value>False</value></param>
<param><key>port</key><value>rigctl_port</value></param>
<param><key>interval</key><value>1000/doppler_correction_per_sec</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value>waterfall_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>8</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/waterfall.dat</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>satnogs_ogg_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>satnogs_iq_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_coarse_doppler_correction_cc_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_tcp_rigctl_msg_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
</flow_graph>
