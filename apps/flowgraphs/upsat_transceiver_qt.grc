<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>upsat_transceiver_qt</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>comment</key><value>FSK baud rate</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>BB Gain RX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain_tx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>BB Gain TX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_rx</value></param>
<param><key>comment</key><value>Decimation factor
for the RX after the
SDR received samples</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>comment</key><value>The FSK frequency deviation</value></param>
<param><key>value</key><value>3.9973e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gaussian_taps</value></param>
<param><key>value</key><value>filter.firdes.gaussian(1.0, samples_per_symbol_tx, 1.0, 4*samples_per_symbol_tx)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>IF Gain RX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain_tx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>IF Gain TX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_taps</value></param>
<param><key>value</key><value>numpy.convolve(numpy.array(gaussian_taps), numpy.array(sq_wave))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation_index</value></param>
<param><key>value</key><value>deviation / (baud_rate / 2.0)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>RF Gain RX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain_tx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>RF Gain TX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>comment</key><value>The RX center frequency
 of the system</value></param>
<param><key>value</key><value>435.765e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol_tx</value></param>
<param><key>comment</key><value>Samples per FSK symbol.
Should be changed only for better
spectrum mask, or if the resampling
is too great and becomes a bottlneck.</value></param>
<param><key>value</key><value>4*8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sq_wave</value></param>
<param><key>value</key><value>(1.0, ) * samples_per_symbol_tx</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>20000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>width</key><value>60000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_frequency</value></param>
<param><key>comment</key><value>The TX center frequency
 of the system</value></param>
<param><key>value</key><value>145.835e6</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>(math.pi*modulation_index) / samples_per_symbol_tx</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>((samp_rate_rx/decimation_rx) / baud_rate)/(math.pi*modulation_index)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>lo_offset </value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_tx</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dest_addr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>(samp_rate_rx/decimation_rx)/baud_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>lo_offset</value></param>
<param><key>decim</key><value>decimation_rx</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>samples_per_symbol_tx</value></param>
<param><key>taps</key><value>interp_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>bb_gain_tx</value></param>
<param><key>bw0</key><value>samp_rate_tx</value></param>
<param><key>freq0</key><value>tx_frequency - lo_offset</value></param>
<param><key>if_gain0</key><value>if_gain_tx</value></param>
<param><key>gain0</key><value>rf_gain_tx</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_tx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain_rx</value></param>
<param><key>bw0</key><value>samp_rate_rx</value></param>
<param><key>freq0</key><value>rx_frequency - lo_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain_rx</value></param>
<param><key>gain0</key><value>rf_gain_rx</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>samp_rate_tx / (baud_rate * samples_per_symbol_tx)</value></param>
<param><key>atten</key><value>60</value></param>
<param><key>taps</key><value>firdes.low_pass_2(32, 32, 0.8, 0.1, 60)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_rx/decimation_rx</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>satnogs_ax25_decoder_bm</key>
<param><key>id</key><value>satnogs_ax25_decoder_bm_0</value></param>
<param><key>descrambling</key><value>True</value></param>
<param><key>max_frame_len</key><value>256</value></param>
<param><key>promisc</key><value>False</value></param>
<param><key>addr</key><value>'GND'</value></param>
<param><key>ssid</key><value>0</value></param>
</block>
<block>
<key>satnogs_debug_msg_source</key>
<param><key>id</key><value>satnogs_debug_msg_source_0</value></param>
<param><key>delay</key><value>0.4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>'HELLO UPSAT FROM EARTH' * 3</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0_0_0</value></param>
<param><key>format</key><value>1</value></param>
</block>
<block>
<key>satnogs_qb50_deframer</key>
<param><key>id</key><value>satnogs_qb50_deframer_0</value></param>
<param><key>wod_ssid</key><value>0xe</value></param>
</block>
<block>
<key>satnogs_udp_msg_sink</key>
<param><key>id</key><value>satnogs_udp_msg_sink_0_0_0</value></param>
<param><key>addr</key><value>dest_addr</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>send_port</value></param>
</block>
<block>
<key>satnogs_udp_msg_sink</key>
<param><key>id</key><value>satnogs_udp_msg_sink_0_0_0_0</value></param>
<param><key>addr</key><value>dest_addr</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>wod_port</value></param>
</block>
<block>
<key>satnogs_udp_msg_source</key>
<param><key>id</key><value>satnogs_udp_msg_source_0</value></param>
<param><key>comment</key><value>The transmitter can also receive payloads 
from a UDP source. Use netcat or something
similar to produce dynamic payloads.</value></param>
<param><key>addr</key><value>"0.0.0.0"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>16886</value></param>
</block>
<block>
<key>satnogs_upsat_fsk_frame_encoder</key>
<param><key>id</key><value>satnogs_upsat_fsk_frame_encoder_0</value></param>
<param><key>append_crc</key><value>False</value></param>
<param><key>dest_addr</key><value>ON02GR</value></param>
<param><key>dest_ssid</key><value>0</value></param>
<param><key>preamble</key><value>[0x33]*8 </value></param>
<param><key>settling_samples</key><value>64</value></param>
<param><key>msb_first</key><value>True</value></param>
<param><key>src_addr</key><value>ABCD</value></param>
<param><key>src_ssid</key><value>0</value></param>
<param><key>sync_word</key><value>[0x7A, 0x0E]</value></param>
<param><key>ax_25</key><value>True</value></param>
<param><key>manchester</key><value>False</value></param>
<param><key>whitening</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>send_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5022</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wod_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5023</value></param>
</block>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>satnogs_ax25_decoder_bm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_bm_0</source_block_id><sink_block_id>satnogs_qb50_deframer_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_debug_msg_source_0</source_block_id><sink_block_id>satnogs_upsat_fsk_frame_encoder_0</sink_block_id><source_key>msg</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>satnogs_qb50_deframer_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_qb50_deframer_0</source_block_id><sink_block_id>satnogs_udp_msg_sink_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_qb50_deframer_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0_0_0</sink_block_id><source_key>wod</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_qb50_deframer_0</source_block_id><sink_block_id>satnogs_udp_msg_sink_0_0_0_0</sink_block_id><source_key>wod</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_udp_msg_source_0</source_block_id><sink_block_id>satnogs_upsat_fsk_frame_encoder_0</sink_block_id><source_key>msg</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>satnogs_upsat_fsk_frame_encoder_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
