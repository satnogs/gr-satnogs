<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>debug_afsk_transceiver_osmocom</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>atten</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>label</key><value>Attenuation</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>comment</key><value>FSK baud rate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>comment</key><value>The FSK frequency deviation</value></param>
<param><key>value</key><value>800</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gaussian_taps</value></param>
<param><key>value</key><value>filter.firdes.gaussian(1.0, samples_per_symbol_tx, 1.0, 4*samples_per_symbol_tx)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_taps</value></param>
<param><key>value</key><value>numpy.convolve(numpy.array(gaussian_taps), numpy.array(sq_wave))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation_index</value></param>
<param><key>value</key><value>deviation / (baud_rate / 2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol_tx</value></param>
<param><key>comment</key><value>Samples per FSK symbol.
Should be changed only for better
spectrum mask, or if the resampling
is too great and becomes a bottlneck.</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sq_wave</value></param>
<param><key>value</key><value>(1.0, ) * samples_per_symbol_tx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_frequency</value></param>
<param><key>comment</key><value>The TX center frequency
 of the system</value></param>
<param><key>value</key><value>145.835e6</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>(math.pi*modulation_index) / samples_per_symbol_tx</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>48e3/(2*math.pi*deviation/8.0)</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>atten</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain_mu</key><value>0.05</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>8.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>samples_per_symbol_tx</value></param>
<param><key>taps</key><value>interp_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>48e3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>baud_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>satnogs_debug_msg_source</key>
<param><key>id</key><value>satnogs_debug_msg_source_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>msg</key><value>"HELLO"*4</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>format</key><value>0</value></param>
</block>
<block>
<key>satnogs_udp_msg_source</key>
<param><key>id</key><value>satnogs_udp_msg_source_0</value></param>
<param><key>comment</key><value>The transmitter can also receive payloads 
from a UDP source. Use netcat or something
similar to produce dynamic payloads.</value></param>
<param><key>addr</key><value>"127.0.0.1"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>16886</value></param>
</block>
<block>
<key>satnogs_upsat_fsk_frame_acquisition</key>
<param><key>id</key><value>satnogs_upsat_fsk_frame_acquisition_0</value></param>
<param><key>check_crc</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>preamble</key><value>[0x33]*8 </value></param>
<param><key>sync_word</key><value>[0x7A, 0x0E]</value></param>
<param><key>ax_25</key><value>True</value></param>
<param><key>manchester</key><value>False</value></param>
<param><key>whitening</key><value>False</value></param>
</block>
<block>
<key>satnogs_upsat_fsk_frame_encoder</key>
<param><key>id</key><value>satnogs_upsat_fsk_frame_encoder_0</value></param>
<param><key>append_crc</key><value>False</value></param>
<param><key>dest_addr</key><value>UPSAT</value></param>
<param><key>dest_ssid</key><value>0</value></param>
<param><key>preamble</key><value>[0x33]*8</value></param>
<param><key>settling_samples</key><value>1024</value></param>
<param><key>msb_first</key><value>True</value></param>
<param><key>src_addr</key><value>ABCD</value></param>
<param><key>src_ssid</key><value>0</value></param>
<param><key>sync_word</key><value>[0x7A, 0x0E]</value></param>
<param><key>ax_25</key><value>True</value></param>
<param><key>manchester</key><value>False</value></param>
<param><key>whitening</key><value>False</value></param>
</block>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>satnogs_upsat_fsk_frame_acquisition_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_debug_msg_source_0</source_block_id><sink_block_id>satnogs_upsat_fsk_frame_encoder_0</sink_block_id><source_key>msg</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>satnogs_udp_msg_source_0</source_block_id><sink_block_id>satnogs_upsat_fsk_frame_encoder_0</sink_block_id><source_key>msg</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>satnogs_upsat_fsk_frame_acquisition_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_upsat_fsk_frame_encoder_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
