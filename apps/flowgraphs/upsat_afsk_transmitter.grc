<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>debug_afsk_transceiver_osmocom</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>atten</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>label</key><value>Attenuation</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>comment</key><value>FSK baud rate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>comment</key><value>The FSK frequency deviation</value></param>
<param><key>value</key><value>1.19e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation_index</value></param>
<param><key>value</key><value>deviation / (baud_rate / 2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol_tx</value></param>
<param><key>comment</key><value>Samples per FSK symbol.
Should be changed only for better
spectrum mask, or if the resampling
is too great and becomes a bottlneck.</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_frequency</value></param>
<param><key>comment</key><value>The TX center frequency
 of the system</value></param>
<param><key>value</key><value>145.835e6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-atten</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>samples_per_symbol_tx</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>satnogs_debug_msg_source</key>
<param><key>id</key><value>satnogs_debug_msg_source_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>msg</key><value>"HELLO"</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>satnogs_udp_msg_source</key>
<param><key>id</key><value>satnogs_udp_msg_source_0</value></param>
<param><key>comment</key><value>The transmitter can also receive payloads 
from a UDP source. Use netcat or something
similar to produce dynamic payloads.</value></param>
<param><key>addr</key><value>"127.0.0.1"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>16886</value></param>
</block>
<block>
<key>satnogs_upsat_fsk_frame_encoder</key>
<param><key>id</key><value>satnogs_upsat_fsk_frame_encoder_0</value></param>
<param><key>append_crc</key><value>False</value></param>
<param><key>dest_addr</key><value>UPSAT</value></param>
<param><key>dest_ssid</key><value>0</value></param>
<param><key>preamble</key><value>[0x33]*8</value></param>
<param><key>settling_samples</key><value>1024</value></param>
<param><key>msb_first</key><value>True</value></param>
<param><key>src_addr</key><value>ABCD</value></param>
<param><key>src_ssid</key><value>0</value></param>
<param><key>sync_word</key><value>[0x7A, 0x0E]</value></param>
<param><key>ax_25</key><value>True</value></param>
<param><key>manchester</key><value>False</value></param>
<param><key>whitening</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_debug_msg_source_0</source_block_id><sink_block_id>satnogs_upsat_fsk_frame_encoder_0</sink_block_id><source_key>msg</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>satnogs_udp_msg_source_0</source_block_id><sink_block_id>satnogs_upsat_fsk_frame_encoder_0</sink_block_id><source_key>msg</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>satnogs_upsat_fsk_frame_encoder_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
